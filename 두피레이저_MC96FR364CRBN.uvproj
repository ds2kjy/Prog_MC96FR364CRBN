# Keil uVision project 두피레이저_MC96FR364CRBN.uvproj, settings and files
target Target 1 (MCS-51)
  device: M8051EW Mentor Graphics Co.
  cpu: IRAM(0 - 0xFF) XRAM(0-0xFFFF) IROM(0-0xFFFF) CLOCK(12000000) MOD517DP
  output: 두피레이저_MC96FR364CRBN +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: startup.a51 main.c interrupt.c peripheral.c Reg.c aIVR8511.c Display.c Util.c Key.C subroutine.c flash_program_entry.asm
